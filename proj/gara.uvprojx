# Keil uVision project gara.uvprojx, settings and files
target gara (6240000::V6.24::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: gara
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER
STM32F10X_MD
  c include: ..\inc;..\lib\CMSIS\CM3\CoreSupport;..\lib\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\lib\FreeRTOS\include;..\lib\FreeRTOS\portable\GCC\ARM_CM3;..\lib\SPL\inc;..\lib\Config
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group src
    ../src/: driver_display_storage.c driver_gate_sensor.c main.c task_gate_sensor.c task_parking_display.c
  group inc
    ../inc/: driver_display_storage.h driver_gate_sensor.h task_parking_display.h app_common.h task_gate_sensor.h
  group CMSIS
    ../lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group FreeRTOS
    ../lib/FreeRTOS/Kernel/: list.c queue.c tasks.c timers.c
    ../lib/FreeRTOS/portable/GCC/ARM_CM3/: port.c
    ../lib/FreeRTOS/portable/MemMang/: heap_4.c
  group SPL
    ../lib/SPL/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
